<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>beacon_rx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>l_band_freq</value></param>
<param><key>value</key><value>freq - lo_freq</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>label</key><value>Alpha coefficient for exponentially-weighted averaging.</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>beacon_beacon_sink_c</key>
<param><key>id</key><value>beacon_beacon_sink_c_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>fft_len</key><value>fftlen</value></param>
<param><key>log_period</key><value>period</value></param>
<param><key>ref_ampl</key><value>1.0</value></param>
<param><key>ref_cnr</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT Lenth</value></param>
<param><key>short_id</key><value>N</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Beacon Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>11701e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_freq</value></param>
<param><key>label</key><value>LO Frequency</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10750e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>period</value></param>
<param><key>label</key><value>Logging period in seconds</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>l_band_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>240e3</value></param>
</block>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>beacon_beacon_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
