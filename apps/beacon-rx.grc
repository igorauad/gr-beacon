options:
  parameters:
    generate_options: no_gui
    id: beacon_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: l_band_freq
  id: variable
  parameters:
    value: freq - lo_freq
  states: {}
- name: alpha
  id: parameter
  parameters:
    label: Alpha coefficient for exponentially-weighted averaging.
    short_id: a
    type: eng_float
    value: '0.01'
  states: {}
- name: beacon_beacon_sink_c_0
  id: beacon_beacon_sink_c
  parameters:
    alpha: alpha
    fft_len: fftlen
    log_period: period
    ref_ampl: '1.0'
    ref_cnr: '1.0'
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT Lenth
    short_id: N
    type: intx
    value: '512'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Beacon Frequency
    short_id: f
    type: eng_float
    value: 11701e6
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    short_id: l
    type: eng_float
    value: 10750e6
  states: {}
- name: period
  id: parameter
  parameters:
    label: Logging period in seconds
    short_id: p
    type: eng_float
    value: '1'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: l_band_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 240e3
  states: {}

connections:
- [rtlsdr_source_0, '0', beacon_beacon_sink_c_0, '0']

metadata:
  file_format: 1
